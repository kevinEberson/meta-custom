require ninvaders.inc

SRC_URI = "https://sourceforge.net/projects/${PN}/files/${PN}/${PV}/${PN}-${PV}.tar.gz"
SRC_URI[md5sum] = "97b2c3fb082241ab5c56ab728522622b"
